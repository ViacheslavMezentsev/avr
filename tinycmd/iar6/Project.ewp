# IAR project Project.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x10
  General.SCRStackSize: 10
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-ec_nomul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: tiny2313 ATtiny2313
  ICCAVR.IExtraOptions: --string_literals_in_flash
  ICCAVR.newCCIncludePaths: ..\; ..\modbus; ..\modbus\ascii; ..\modbus\functions; ..\modbus\include; ..\modbus\rtu; ..\modbus\tcp; ..\port; ..\modbus\
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  prebuild: ..\prebuild.cmd
  postbuild: ..\postbuild.cmd
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny2313.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-n.h
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ../: CommandShell.cpp Console.cpp MainUnit.cpp MCU.cpp
