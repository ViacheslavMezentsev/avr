# IAR project Project.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 20
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m16 ATmega16
  ICCAVR.newCCIncludePaths: ..\; ..\modbus; ..\modbus\ascii; ..\modbus\functions; ..\modbus\include; ..\modbus\rtu; ..\modbus\tcp; ..\port; ..\modbus\
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  prebuild: ..\prebuild.cmd
  postbuild: ..\postbuild.cmd
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-n.h
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ../: ISRList.cpp MainUnit.cpp MCU.cpp
  group modbus
    ../modbus/: mb.cpp
  group modbus/ascii
    ../modbus/ascii/: mbascii.cpp
  group modbus/functions
    ../modbus/functions/: mbfunccoils.cpp mbfuncdiag.cpp mbfuncdisc.cpp mbfuncholding.cpp mbfuncinput.cpp mbfuncother.cpp mbutils.cpp
  group modbus/rtu
    ../modbus/rtu/: mbcrc.cpp mbrtu.cpp
  group modbus/tcp
    ../modbus/tcp/: mbtcp.cpp
  group port
    ../port/: portevent.cpp portserial.cpp porttimer.cpp
